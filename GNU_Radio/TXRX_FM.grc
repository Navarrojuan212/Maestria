options:
  parameters:
    author: captain
    generate_options: qt_gui
    id: TxRx_FM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Frec_Tomada
  id: variable_qtgui_range
  parameters:
    label: Frecuencia variable entre 80MHz y 480MHz - Rx_A1
    start: 80e6
    step: 0.1e6
    stop: 480e6
    value: 107.15e6
  states: {}
- name: Frec_TxRx_A1
  id: variable_qtgui_range
  parameters:
    label: Frecuencia variable entre 80MHz y 480MHz - TXRX_A1
    start: 80e6
    step: 0.1e6
    stop: 480e6
    value: 400e6
  states: {}
- name: Frec_TxRx_B1
  id: variable_qtgui_range
  parameters:
    label: Frecuencia variable entre 1MHz y 250MHz - TxRx_B1
    start: 70e6
    step: 0.1e6
    stop: 500e6
    value: 100e6
  states: {}
- name: Gain
  id: variable_qtgui_range
  parameters:
    label: Ganancia RF Rx_A1
    start: '0'
    step: '1'
    stop: '80'
    value: '30'
  states: {}
- name: Gain_TxRx_A1
  id: variable_qtgui_range
  parameters:
    label: Ganancia RF TxRx_A1
    start: '0'
    step: '1'
    stop: '80'
    value: '30'
  states: {}
- name: Gain_TxRx_B1
  id: variable_qtgui_range
  parameters:
    label: Ganancia RF TxRx_B1
    start: '0'
    step: '1'
    stop: '80'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-250e3'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,140e3,10e3)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: Frec_Tomada
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_1_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: Frec_TxRx_A1
    center_freq1: Frec_TxRx_B1
    clock_source0: internal
    dev_addr: '"serial=30B5874"'
    gain0: Gain_TxRx_A1
    gain1: Gain_TxRx_B1
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: Frec_Tomada
    clock_source0: external
    dev_addr: '"serial=30B584D"'
    gain0: Gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', uhd_usrp_sink_1_0, '1']
- [dc_blocker_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', uhd_usrp_sink_1_0, '0']
- [uhd_usrp_source_0, '0', dc_blocker_xx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
