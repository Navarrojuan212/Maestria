options:
  parameters:
    author: captain
    generate_options: qt_gui
    id: TxRx_FM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Frec_RF_Out
  id: variable_qtgui_range
  parameters:
    label: Frecuencia RF Out
    start: 25e6
    step: 0.1e6
    stop: 500e6
    value: 26e6
  states: {}
- name: Frec_Tomada
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Rx Radio
    start: 80e6
    step: 0.1e6
    stop: 480e6
    value: 107.15e6
  states: {}
- name: Frec_TxRx_A1
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Tx
    start: 80e6
    step: 0.1e6
    stop: 480e6
    value: 140e6
  states: {}
- name: Gain
  id: variable_qtgui_range
  parameters:
    label: Ganancia RF Radio
    start: '0'
    step: '1'
    stop: '80'
    value: '39'
  states: {}
- name: Gain_RF_Out
  id: variable_qtgui_range
  parameters:
    label: Ganancia RF Out
    start: '0'
    step: '1'
    stop: '80'
    value: '23'
  states: {}
- name: Gain_TxRx_A1
  id: variable_qtgui_range
  parameters:
    label: Ganancia Tx
    start: '0'
    step: '1'
    stop: '80'
    value: '40'
  states: {}
- name: f_factor
  id: variable
  parameters:
    value: '40'
  states: {}
- name: fol
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de oscilador local
    start: 80e6
    step: 0.1e6
    stop: 480e6
    value: 165.65e6
  states: {}
- name: gol
  id: variable_qtgui_range
  parameters:
    label: Ganancia oscilador local
    start: '0'
    step: '1'
    stop: '80'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    label: Volumen
    start: '-40'
    step: '1'
    stop: '10'
    value: '-10'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    quad_rate: samp_rate*f_factor/4
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(vol/10)
    type: float
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-250e3'
    decim: '1'
    samp_rate: samp_rate*f_factor
    taps: firdes.low_pass(1,samp_rate*f_factor,140e3,10e3)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-250e3'
    decim: '4'
    samp_rate: samp_rate*f_factor
    taps: firdes.low_pass(1,samp_rate*f_factor,140e3,10e3)
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    decim: '5'
    gain: '1'
    samp_rate: samp_rate*f_factor/8
    type: fir_filter_fff
    width: 3e3
    win: window.WIN_HAMMING
  states: {}
- name: nb
  id: qtgui_tab_widget
  parameters:
    label0: Spectrum RF Input
    label1: Spectrum RF Output
    num_tabs: '2'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: Frec_RF_Out
    gain0: Gain_RF_Out
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate*f_factor
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*f_factor
    ctrlpanel: 'True'
    fc: Frec_Tomada
    fftsize: '1024'
    gui_hint: nb@0
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*f_factor
    ctrlpanel: 'True'
    fc: Frec_RF_Out
    fftsize: '1024'
    gui_hint: nb@1
    type: complex
  states: {}
- name: uhd_usrp_sink_1_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Frec_TxRx_A1
    clock_source0: internal
    dev_addr: '"serial=30B584D"'
    gain0: Gain_TxRx_A1
    samp_rate: samp_rate*f_factor
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_sink_1_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: fol
    center_freq1: fol
    clock_source0: internal
    dev_addr: '"serial=30C2C26"'
    gain0: gol
    gain1: gol
    nchan: '2'
    samp_rate: samp_rate*f_factor
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: Frec_Tomada
    clock_source0: external
    dev_addr: '"serial=30B584D"'
    gain0: Gain
    samp_rate: samp_rate*f_factor
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', uhd_usrp_sink_1_0_0, '0']
- [analog_const_source_x_0, '0', uhd_usrp_sink_1_0_0, '1']
- [analog_wfm_rcv_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [dc_blocker_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [dc_blocker_xx_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', uhd_usrp_sink_1_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [osmosdr_source_0, '0', dc_blocker_xx_0_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', dc_blocker_xx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
