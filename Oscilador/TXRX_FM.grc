options:
  parameters:
    author: captain
    generate_options: qt_gui
    id: TxRx_FM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: f_factor
  id: variable
  parameters:
    value: '40'
  states: {}
- name: fol
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de oscilador local
    outputmsgname: value
    showports: 'False'
    start: 80e6
    step: 0.1e6
    stop: 480e6
    value: 142e6
  states: {}
- name: gol
  id: variable_qtgui_range
  parameters:
    label: Ganancia oscilador local
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '80'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: nb
  id: qtgui_tab_widget
  parameters:
    label0: Spectrum RF Input
    label1: Spectrum RF Output
    num_tabs: '2'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fol
    dev_addr: '"serial=30B5874"'
    gain0: gol
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
